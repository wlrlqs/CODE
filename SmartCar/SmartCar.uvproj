# Keil uVision project SmartCar.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: SmartCar +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: Bluetooth.c EMcontrol.c Infrared.c main.c PWMcontrol.c Oled.c UltraSonic.c
