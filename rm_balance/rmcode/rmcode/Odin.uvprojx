# Keil uVision project Odin.uvprojx, settings and files
target Odin (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Odin +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --c99
  c include: .\Libraries\CMSIS\Include;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\FreeRTOS\portable\MemMang;.\Applications;.\Driver;.\BSP;.\Math;.\Utility;.\Libraries\USB\STM32_USB_APP\USB_Device_Examples\VCP;.\Libraries\USB\STM32_USB_Device_Library\Core;.\Libraries\USB\STM32_USB_Device_Library\Class\cdc;.\Libraries\USB\STM32_USB_OTG_Driver;.\Libraries\FATFS\src;.\GUI;.\SEEGER\RTT;.\CAN_FD;.\custom_demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\Odin.sct
  group autotask
    ./Applications/: auto_infantry.c auto_auxiliary.c auto_sentry.c auto_tank.c auto_task.c auto_uav.c
  group app
    ./Applications/: app_Init.c bufferLoop_mod.c cansend.c control.c chassis.c clockcount.c crc.c data_transmission.c deforming.c differential_calculation.c gimbal.c imu.c iir_filter.c joint.c keyboard.c main.c missile.c motorHandle.c pid.c power.c pneumatic.c processing.c rc.c shoot.c slave_sensor.c slave_sensor_mod.c supervisor.c transfer_receive.c interrupt_service_fun.c type_robot.c vision.c warning.c wireless.c supercapacitor.c
  group driver
    ./Driver/: Driver_ADC.c Driver_Beep.c Driver_ClockCount.c Driver_Coder.c Driver_DMMotor.c Driver_DTU.c Driver_Flash.c Driver_icm42605.c Driver_imuSC.c Driver_ITV.c Driver_Judge.c Driver_Motor_Dshot.c Driver_MotorSever.c Driver_MPU6500.c Driver_Multi_Master.c Driver_M1502AMotor.c Driver_RMDMotor.c Driver_RMMotor.c Driver_RMDT7.c Driver_SDCard.c Driver_SK6812.c Driver_Slave_Sensor.c Driver_USBVCP.c Driver_VL53L0X.c Driver_Power.c Driver_powerContol.c Driver_Servo.c Driver_WT931.c Driver_unitreeMotor.c Driver_UserPrintf.c
  group isp
    ./Driver/: ISP_USART.c ISP_TIM.c ISP_SPI.c ISP_EXIT.c ISP_CAN.c
  group sys_config
    ./Applications/: judge.c config.c local_id.c tf_card_parameter.c parameter.c
  group sys
    ./sys/: bsp.lib math.lib
  group util
    ./Utility/: Util.c cpu_utils.c
  group CMSIS
    ./Libraries/CMSIS/Include/: arm_cortexM4lf_math.lib startup_stm32f427xx.s
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group SEGGER/RTT
    ./SEEGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group NOTE
    ./note/: STM32F4xx_DMA_Map.txt
  group CAN-FD
    ./CAN_FD/: canfd.c drv_canfd_api.c
  group type_can_isp
    ./Applications/: infantry_can_isp.c tank_can_isp.c auxiliary_can_isp.c sentry_can_isp.c smallGimbal_can_isp.c uav_can_isp.c
  group custom_demo
    ./custom_demo/: broadcast_demo.c custom_broadcast.c driver_crc.c
